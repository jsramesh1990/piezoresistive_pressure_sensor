FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://ads1115.cfg"

# You may need to adjust the kernel recipe name depending on your BSP
